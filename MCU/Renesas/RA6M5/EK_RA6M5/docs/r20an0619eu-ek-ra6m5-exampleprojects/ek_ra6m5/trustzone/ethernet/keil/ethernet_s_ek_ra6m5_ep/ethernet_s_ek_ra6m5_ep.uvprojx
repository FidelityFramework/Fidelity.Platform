# Keil uVision project ethernet_s_ek_ra6m5_ep.uvprojx, settings and files
target Target 1 (6230000::V6.23::.\ArmCompilerforEmbedded6.23)
  device: R7FA6M5BH Renesas
  pack: Renesas.RA_DFP.5.9.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ  FPU3(SFPU)  CLOCK(12000000) ELITTLE
  output: ethernet_s_ek_ra6m5_ep +hex
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" "$PUserNscApiFiles.txt" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: Optim=3 v6Lang=3 v6LangP=6
  c define: _RA_TZ_SECURE
  c misc: @via/rasc_armclang.via
  asm misc: --via=via/rasc_armasm.via
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via --import_cmse_lib_out="$Lsecure.o"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
